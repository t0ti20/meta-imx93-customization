# Upstream rewrote master's history; the SRCREV pinned by meta-security no
# longer exists on the branch. Bump to current master HEAD (verified via
# `git ls-remote https://github.com/google/fscrypt.git master` on 2026-08-22).
SRCREV = "ed08dee50fa7d906c6539bba8fa24e14aee6e516"
